# Keil uVision project ucosiii.uvprojx, settings and files
target ucosiii (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ucosiii
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_STM3210B_EVAL,USE_SDIO_SD
  c include: ..\APP;..\CORE;..\DRIVERS;..\LIBRRARY;..\MAIN;..\MODULES;..\STM32F10x_StdPeriph_Driver\inc;..\STM32_USB-Driver\inc;..\STM32_USB-FS-Device_Driver\inc;..\uCOS-III\uC-CPU;..\uCOS-III\uC-LIB;..\uCOS-III\uCOS-III
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group APP
    ../APP/: APP.c
  group CORE
    ../CORE/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s
  group MAIN
    ../MAIN/: main.c
  group STM32F10x_StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32_USB-FS-Device_Driver
    ../STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32_USB-Driver
    ../STM32_USB-Driver/src/: hw_config.c mass_mal.c memory.c scsi_data.c stm3210b_eval.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group uC-CPU
    ../uCOS-III/uC-CPU/: cpu_c.c cpu_core.c cpu_a.s
  group uC-LIB
    ../uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_mem_a.asm
  group uC-III
    ../uCOS-III/uCOS-III/: os_app_hooks.c os_cfg_app.c os_core.c os_cpu_c.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c os_cpu_a.s
  group DRIVERS
    ../DRIVERS/AD/: ad.c
    ../DRIVERS/CAN/: can.c
    ../DRIVERS/delay/: delay.c
    ../DRIVERS/FLASH_ST/: flash_st.c
    ../DRIVERS/IIC/: iic.c
    ../DRIVERS/INIT/: init.c
    ../DRIVERS/SPI/: spi.c
    ../DRIVERS/UART/: usart.c
    ../DRIVERS/DAC/: da.c
  group LIBRARY
    ../LIBRRARY/FAST_COPY/: fast_copy.c
    ../LIBRRARY/FAT32/: ff.c diskio.c ffsystem.c ffunicode.c
    ../LIBRRARY/GUI/: GUI.c
    ../LIBRRARY/MATH/: math_stm.c
    ../LIBRRARY/MESSG_DATA/: messg_recive.c messg_send.c
  group MODULES
    ../MODULES/DHT11/: dht11.c
    ../MODULES/FM25V01/: fm25v01.c
    ../MODULES/LCD_OLED/: Lcd_Driver.c
    ../MODULES/LED/: led.c
    ../MODULES/MPU9250/: mpu9250.c
    ../MODULES/SDIO_SD/: stm32_eval_sdio_sd.c
    ../MODULES/SIM7600/: sim7600.c
    ../MODULES/TCA62724/: tca62724.c
    ../MODULES/WIFI_ESP/: wifi_esp.c
